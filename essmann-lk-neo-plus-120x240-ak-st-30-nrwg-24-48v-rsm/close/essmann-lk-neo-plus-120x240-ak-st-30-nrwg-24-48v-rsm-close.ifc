Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_206/temp/tmp_8308_43_3oSsJ/format_1/300120240O227CN1NNY1010.ifc
Time: 2026-04-30T13:05:42
Made in: PARTsolutions

# IfcDiscreteAccessory, 300120240O227CN1NNY1010
In: BUILDING
Description: LKneoplus120240O227N1NNY101
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN; ArticleNumber: 300120240O227CN1NNY1010
ePset_PARTsolutions - NB: 300120240O227CN1NNY1010; NN: LK neo plus; NBSYN: $LODLEVEL.$L.$W.$TG.$TS.$DP.$OP.$OC.$GCW.$SD.$IPM.$EVADSS.$SSSO.$BA.$INS.$RT.; LINA: LKneoplus120240O227N1NNY101; CATALOG: Light + Air; PN: LK neo plus; LODLEVEL: 300; L: 120; W: 240; TG: opal; TS: 3shelled; WF: included; DP: NSHEV; OP: NSHEV 24/48 V LK incl. ventilation function; OC: Closed; GCW: No; SD: RSM - round bar fall-through protection mat; IPM: No; EVADSS: No; BA: AK ST 30; INS: PIR; UVD: 1.9; LT: 47; GV: 62; SI: 22; RT: 0
