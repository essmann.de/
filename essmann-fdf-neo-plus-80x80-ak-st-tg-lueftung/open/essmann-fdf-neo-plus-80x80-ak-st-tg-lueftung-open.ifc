Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_1101/temp/tmp_3264_9_nJK0V/format_1/8080C2111N1N4N(300Op0).ifc
Time: 2026-04-29T08:58:21
Made in: PARTsolutions

# IfcDiscreteAccessory, 8080C2111N1N4N(300Op0)
In: BUILDING
Description: FDFneoplus8080C2111N1N4N
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN; ArticleNumber: 8080C2111N1N4N(300Op0)
ePset_PARTsolutions - NB: 8080C2111N1N4N(300Op0); NN: FDF neo plus; NBSYN: $L.$W.$TG.$TG1.$BA.$DP.$OP.$GCW.$SD.$IPM.$SSSO.$GPI1.($LODLEVEL.$OC.$RT.); LINA: FDFneoplus8080C2111N1N4N; CATALOG: Light + Air; PN: FDF neo plus; LODLEVEL: 300; L: 80; W: 80; TG: clear; TG1: 2 layer heat insulation glazing clear; SF: included; BA: Thermal brokeb steel upstand, inclined 50 cm; DP: Natural ventilation; OP: Linear Drive 300mm stroke 24V or 230V; GCW: No; SD: No; IPM: No; SSSO: No; GPI: No; OC: Open; UVD: 1.1; LT: 79; GV: 58; SI: 39; RT: 0
