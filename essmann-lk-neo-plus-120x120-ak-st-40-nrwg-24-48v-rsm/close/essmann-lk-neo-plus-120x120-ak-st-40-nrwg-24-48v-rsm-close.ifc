Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_154/temp/tmp_6604_55_E6lk7/format_1/300120120O227CN1NNY1110.ifc
Time: 2026-04-30T13:01:07
Made in: PARTsolutions

# IfcDiscreteAccessory, 300120120O227CN1NNY1110
In: BUILDING
Description: LKneoplus120120O227N1NNY111
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN; ArticleNumber: 300120120O227CN1NNY1110
ePset_PARTsolutions - NB: 300120120O227CN1NNY1110; NN: LK neo plus; NBSYN: $LODLEVEL.$L.$W.$TG.$TS.$DP.$OP.$OC.$GCW.$SD.$IPM.$EVADSS.$SSSO.$BA.$INS.$RT.; LINA: LKneoplus120120O227N1NNY111; CATALOG: Light + Air; PN: LK neo plus; LODLEVEL: 300; L: 120; W: 120; TG: opal; TS: 3shelled; WF: included; DP: NSHEV; OP: NSHEV 24/48 V LK incl. ventilation function; OC: Closed; GCW: No; SD: RSM - round bar fall-through protection mat; IPM: No; EVADSS: No; BA: AK ST 40; INS: PIR; UVD: 1.9; LT: 47; GV: 62; SI: 22; RT: 0
