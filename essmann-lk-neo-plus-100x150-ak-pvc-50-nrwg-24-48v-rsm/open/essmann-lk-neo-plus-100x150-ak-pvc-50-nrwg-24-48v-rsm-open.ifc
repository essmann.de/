Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_189/temp/tmp_5980_33_NzNpL/format_0/300100150O227ON1NNY310.ifc
Time: 2026-04-30T12:57:29
Made in: PARTsolutions

# IfcDiscreteAccessory
In: BUILDING
Description: LKneoplus100150O227N1NNY31
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN
ePset_PARTsolutions - NN: LK neo plus; NBSYN: $LODLEVEL.$L.$W.$TG.$TS.$DP.$OP.$OC.$GCW.$SD.$IPM.$EVADSS.$SSSO.$BA.$INS.$RT.; LINA: LKneoplus100150O227N1NNY31; CATALOG: Light + Air; PN: LK neo plus; LODLEVEL: 300; L: 100; W: 150; TG: opal; TS: 3shelled; WF: included; DP: NSHEV; OP: NSHEV 24/48 V LK incl. ventilation function; OC: Open; GCW: No; SD: RSM - round bar fall-through protection mat; IPM: No; EVADSS: No; BA: AK PVC 50; INS: i - insulation; UVD: 1.9; LT: 47; GV: 62; SI: 22; RT: 0
