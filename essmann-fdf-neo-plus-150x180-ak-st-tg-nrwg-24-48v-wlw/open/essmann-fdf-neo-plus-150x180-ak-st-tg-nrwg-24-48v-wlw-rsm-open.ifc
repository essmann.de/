Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_1090/temp/tmp_9296_131_mX8it/format_1/150180C2125Y2N4N(300Op0).ifc
Time: 2026-04-29T08:42:41
Made in: PARTsolutions

# IfcDiscreteAccessory, 150180C2125Y2N4N(300Op0)
In: BUILDING
Description: FDFneoplus150180C2125Y2N4N
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN; ArticleNumber: 150180C2125Y2N4N(300Op0)
ePset_PARTsolutions - NB: 150180C2125Y2N4N(300Op0); NN: FDF neo plus; NBSYN: $L.$W.$TG.$TG1.$BA.$DP.$OP.$GCW.$SD.$IPM.$SSSO.$GPI1.($LODLEVEL.$OC.$RT.); LINA: FDFneoplus150180C2125Y2N4N; CATALOG: Light + Air; PN: FDF neo plus; LODLEVEL: 300; L: 150; W: 180; TG: clear; TG1: 2 layer heat insulation glazing clear; SF: included; BA: Thermal brokeb steel upstand, inclined 50 cm; DP: NSHEV (natural smoke heat exhaust ventilation); OP: 24/48 V OPEN/CLOSE including ventilation function; GCW: Yes; SD: Yes; IPM: No; SSSO: No; GPI: No; OC: Open; UVD: 1.1; LT: 79; GV: 58; SI: 39; RT: 0
