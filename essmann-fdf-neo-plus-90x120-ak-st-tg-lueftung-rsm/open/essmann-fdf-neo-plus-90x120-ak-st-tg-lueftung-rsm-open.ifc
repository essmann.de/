Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_1107/temp/tmp_9892_45_AZVT7/format_2/90120C2111N2N4N(300Op0).ifc
Time: 2026-04-29T09:04:22
Made in: PARTsolutions

# IfcDiscreteAccessory, 90120C2111N2N4N(300Op0)
In: BUILDING
Description: FDFneoplus90120C2111N2N4N
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN; ArticleNumber: 90120C2111N2N4N(300Op0)
ePset_PARTsolutions - NB: 90120C2111N2N4N(300Op0); NN: FDF neo plus; NBSYN: $L.$W.$TG.$TG1.$BA.$DP.$OP.$GCW.$SD.$IPM.$SSSO.$GPI1.($LODLEVEL.$OC.$RT.); LINA: FDFneoplus90120C2111N2N4N; CATALOG: Light + Air; PN: FDF neo plus; LODLEVEL: 300; L: 90; W: 120; TG: clear; TG1: 2 layer heat insulation glazing clear; SF: included; BA: Thermal brokeb steel upstand, inclined 50 cm; DP: Natural ventilation; OP: Linear Drive 300mm stroke 24V or 230V; GCW: No; SD: Yes; IPM: No; SSSO: No; GPI: No; OC: Open; UVD: 1.1; LT: 79; GV: 58; SI: 39; RT: 0
