Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_230/temp/tmp_2808_95_fFS6X/format_0/300150150O227ON1NNY1210.ifc
Time: 2026-04-30T13:09:17
Made in: PARTsolutions

# IfcDiscreteAccessory, 300150150O227ON1NNY1210
In: BUILDING
Description: LKneoplus150150O227N1NNY121
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN; ArticleNumber: 300150150O227ON1NNY1210
ePset_PARTsolutions - NB: 300150150O227ON1NNY1210; NN: LK neo plus; NBSYN: $LODLEVEL.$L.$W.$TG.$TS.$DP.$OP.$OC.$GCW.$SD.$IPM.$EVADSS.$SSSO.$BA.$INS.$RT.; LINA: LKneoplus150150O227N1NNY121; CATALOG: Light + Air; PN: LK neo plus; LODLEVEL: 300; L: 150; W: 150; TG: opal; TS: 3shelled; WF: included; DP: NSHEV; OP: NSHEV 24/48 V LK incl. ventilation function; OC: Open; GCW: No; SD: RSM - round bar fall-through protection mat; IPM: No; EVADSS: No; BA: AK ST 50; INS: PIR; UVD: 1.9; LT: 47; GV: 62; SI: 22; RT: 0
