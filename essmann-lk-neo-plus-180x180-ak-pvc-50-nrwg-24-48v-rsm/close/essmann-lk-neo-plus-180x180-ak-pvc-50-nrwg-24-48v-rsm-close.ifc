Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_167/temp/tmp_8124_39_G8ksh/format_0/300180180O227CN1NNY310.ifc
Time: 2026-04-30T13:19:22
Made in: PARTsolutions

# IfcDiscreteAccessory
In: BUILDING
Description: LKneoplus180180O227N1NNY31
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN
ePset_PARTsolutions - NN: LK neo plus; NBSYN: $LODLEVEL.$L.$W.$TG.$TS.$DP.$OP.$OC.$GCW.$SD.$IPM.$EVADSS.$SSSO.$BA.$INS.$RT.; LINA: LKneoplus180180O227N1NNY31; CATALOG: Light + Air; PN: LK neo plus; LODLEVEL: 300; L: 180; W: 180; TG: opal; TS: 3shelled; WF: included; DP: NSHEV; OP: NSHEV 24/48 V LK incl. ventilation function; OC: Closed; GCW: No; SD: RSM - round bar fall-through protection mat; IPM: No; EVADSS: No; BA: AK PVC 50; INS: i - insulation; UVD: 1.9; LT: 47; GV: 62; SI: 22; RT: 0
