Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_1443/temp/tmp_7428_275_cj7UB/format_0/120240C2125Y1N4N(300Op0).ifc
Time: 2026-04-28T14:15:04
Made in: PARTsolutions

# IfcDiscreteAccessory, 120240C2125Y1N4N(300Op0)
In: BUILDING
Description: FDFneoplus120240C2125Y1N4N
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN; ArticleNumber: 120240C2125Y1N4N(300Op0)
ePset_PARTsolutions - NB: 120240C2125Y1N4N(300Op0); NN: FDF neo plus; NBSYN: $L.$W.$TG.$TG1.$BA.$DP.$OP.$GCW.$SD.$IPM.$SSSO.$GPI1.($LODLEVEL.$OC.$RT.); LINA: FDFneoplus120240C2125Y1N4N; CATALOG: Light + Air; PN: FDF neo plus; LODLEVEL: 300; L: 120; W: 240; TG: clear; TG1: 2 layer heat insulation glazing clear; SF: included; BA: Thermal brokeb steel upstand, inclined 50 cm; DP: NSHEV (natural smoke heat exhaust ventilation); OP: 24/48 V OPEN/CLOSE including ventilation function; GCW: Yes; SD: No; IPM: No; SSSO: No; GPI: No; OC: Open; UVD: 1.1; LT: 79; GV: 58; SI: 39; RT: 0
