Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_682/temp/tmp_6976_44_gfGna/format_0/FDFneo6090C2311N1N4N(300Cl0).ifc
Time: 2026-04-28T08:22:50
Made in: PARTsolutions

# IfcDiscreteAccessory, FDFneo6090C2311N1N4N(300Cl0)
In: BUILDING
Description: FDFneo6090C2311N1N4N
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN; ArticleNumber: FDFneo6090C2311N1N4N(300Cl0)
ePset_PARTsolutions - NB: FDFneo6090C2311N1N4N(300Cl0); NN: FDF neo; NBSYN: FDFneo$L.$W.$TG.$TG1.$BA.$DP.$OP.$GCW.$SD.$IPM.$SSSO.$GPI1.($LODLEVEL.$OC.$RT.); LINA: FDFneo6090C2311N1N4N; CATALOG: Light + Air; PN: FDF neo; LODLEVEL: 300; L: 60; W: 90; TG: clear; TG1: 2 layer heat insulation glazing clear; SF: included; BA: Thermal brokeb steel upstand, vertical 6° slope 50 cm; DP: Natural ventilation; OP: Linear Drive 300mm stroke 24V or 230V; GCW: No; SD: No; IPM: No; SSSO: No; GPI: No; OC: Closed; UVD: 1.1; LT: 79; GV: 58; SI: 39; RT: 0
