Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_168/temp/tmp_2852_15_S576x/format_0/300180300O227CN1NNY1210.ifc
Time: 2026-04-30T13:17:41
Made in: PARTsolutions

# IfcDiscreteAccessory, 300180300O227CN1NNY1210
In: BUILDING
Description: LKneoplus180300O227N1NNY121
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN; ArticleNumber: 300180300O227CN1NNY1210
ePset_PARTsolutions - NB: 300180300O227CN1NNY1210; NN: LK neo plus; NBSYN: $LODLEVEL.$L.$W.$TG.$TS.$DP.$OP.$OC.$GCW.$SD.$IPM.$EVADSS.$SSSO.$BA.$INS.$RT.; LINA: LKneoplus180300O227N1NNY121; CATALOG: Light + Air; PN: LK neo plus; LODLEVEL: 300; L: 180; W: 300; TG: opal; TS: 3shelled; WF: included; DP: NSHEV; OP: NSHEV 24/48 V LK incl. ventilation function; OC: Closed; GCW: No; SD: RSM - round bar fall-through protection mat; IPM: No; EVADSS: No; BA: AK ST 50; INS: PIR; UVD: 1.9; LT: 47; GV: 62; SI: 22; RT: 0
