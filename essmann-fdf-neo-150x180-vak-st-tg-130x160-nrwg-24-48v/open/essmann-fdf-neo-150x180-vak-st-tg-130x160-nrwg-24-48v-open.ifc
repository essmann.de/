Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_1120/temp/tmp_3920_30_L3X2j/format_0/FDFneo150180C2225N1N4N(300Op0).ifc
Time: 2026-04-28T13:08:54
Made in: PARTsolutions

# IfcDiscreteAccessory, FDFneo150180C2225N1N4N(300Op0)
In: BUILDING
Description: FDFneo150180C2225N1N4N
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN; ArticleNumber: FDFneo150180C2225N1N4N(300Op0)
ePset_PARTsolutions - NB: FDFneo150180C2225N1N4N(300Op0); NN: FDF neo; NBSYN: FDFneo$L.$W.$TG.$TG1.$BA.$DP.$OP.$GCW.$SD.$IPM.$SSSO.$GPI1.($LODLEVEL.$OC.$RT.); LINA: FDFneo150180C2225N1N4N; CATALOG: Light + Air; PN: FDF neo; LODLEVEL: 300; L: 150; W: 180; TG: clear; TG1: 2 layer heat insulation glazing clear; SF: included; BA: Thermal brokeb steel upstand, vertical 50 cm; DP: NSHEV (natural smoke heat exhaust ventilation); OP: 24/48 V OPEN/CLOSE including ventilation function; GCW: No; SD: No; IPM: No; SSSO: No; GPI: No; OC: Open; UVD: 1.1; LT: 79; GV: 58; SI: 39; RT: 0
