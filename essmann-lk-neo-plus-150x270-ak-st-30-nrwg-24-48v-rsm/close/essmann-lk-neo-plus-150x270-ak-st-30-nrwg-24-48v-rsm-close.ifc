Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_208/temp/tmp_6720_47_4I5IF/format_0/300150270O227CN1NNY1010.ifc
Time: 2026-04-30T13:11:37
Made in: PARTsolutions

# IfcDiscreteAccessory, 300150270O227CN1NNY1010
In: BUILDING
Description: LKneoplus150270O227N1NNY101
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN; ArticleNumber: 300150270O227CN1NNY1010
ePset_PARTsolutions - NB: 300150270O227CN1NNY1010; NN: LK neo plus; NBSYN: $LODLEVEL.$L.$W.$TG.$TS.$DP.$OP.$OC.$GCW.$SD.$IPM.$EVADSS.$SSSO.$BA.$INS.$RT.; LINA: LKneoplus150270O227N1NNY101; CATALOG: Light + Air; PN: LK neo plus; LODLEVEL: 300; L: 150; W: 270; TG: opal; TS: 3shelled; WF: included; DP: NSHEV; OP: NSHEV 24/48 V LK incl. ventilation function; OC: Closed; GCW: No; SD: RSM - round bar fall-through protection mat; IPM: No; EVADSS: No; BA: AK ST 30; INS: PIR; UVD: 1.9; LT: 47; GV: 62; SI: 22; RT: 0
