Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_1393/temp/tmp_7500_0_C9PvM/format_1/FDFneo150150C2125N1N4N(300Cl0).ifc
Time: 2026-04-28T12:32:23
Made in: PARTsolutions

# IfcDiscreteAccessory, FDFneo150150C2125N1N4N(300Cl0)
In: BUILDING
Description: FDFneo150150C2125N1N4N
Pset_ManufacturerTypeInformation - Manufacturer: KINGSPAN; ArticleNumber: FDFneo150150C2125N1N4N(300Cl0)
ePset_PARTsolutions - NB: FDFneo150150C2125N1N4N(300Cl0); NN: FDF neo; NBSYN: FDFneo$L.$W.$TG.$TG1.$BA.$DP.$OP.$GCW.$SD.$IPM.$SSSO.$GPI1.($LODLEVEL.$OC.$RT.); LINA: FDFneo150150C2125N1N4N; CATALOG: Light + Air; PN: FDF neo; LODLEVEL: 300; L: 150; W: 150; TG: clear; TG1: 2 layer heat insulation glazing clear; SF: included; BA: Thermal brokeb steel upstand, inclined 50 cm; DP: NSHEV (natural smoke heat exhaust ventilation); OP: 24/48 V OPEN/CLOSE including ventilation function; GCW: No; SD: No; IPM: No; SSSO: No; GPI: No; OC: Closed; UVD: 1.1; LT: 79; GV: 58; SI: 39; RT: 0
